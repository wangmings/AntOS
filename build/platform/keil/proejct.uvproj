# Keil uVision project proejct.uvproj, settings and files
target AntOS (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: antos +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\AntOS;..\..\..\arch\8051;..\..\..\kernel\inc;..\..\..\kernel\src;..\..\..\libs\inc;..\..\..\libs\src;..\..\..\serve\inc;..\..\..\serve\src;..\..\..\adf;..\..\..\adf\startup\stc\stc8;..\..\..\adf\bsp\open-ell;..\..\..\adf\bsp\open-ell\peripherals;..\..\..\adf\bsp\open-ell\peripherals\STC8x\inc;..\..\..\adf\bsp\open-ell\peripherals\STC8x\src;..\..\..\adf\bsp\open-ell\core;..\..\..\adf\bsp\open-ell\core\register\STC8x;..\..\..\adf\bsp\open-ell\core\startup\STC8x;..\..\..\app\user;..\..\..\app\main
  link misc: REMOVEUNUSED
  group adf/startup
    ../../../adf/startup/stc/stc8/: startup.s
  group adf/bsp
    ../../../adf/bsp/open-ell/: ELL_CFG.h
    ../../../adf/bsp/open-ell/peripherals/STC8x/src/: STC8x_SYSCLK.c STC8x_TIMER.c STC8x_UART.c STC8x_GPIO.c STC8x_RST.c
  group os/arch
    ../../../arch/8051/: os_cpu.c
  group os/kernel
    ../../../: os_cfg.h
    ../../../kernel/src/: os_core.c os_thread.c
  group os/libs
    ../../../libs/inc/: os_type.h
    ../../../libs/src/: os_mem.c os_object.c
  group app/main
    ../../../app/main/: init.c isr.c main.c
  group build
    ./link/: lx51_cfg
